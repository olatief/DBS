# IAR project ElecStim.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F32 EnergyMicro EFM32TG210F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG210F32; DEBUG_EFM
  ICCARM.CCIncludePath2: common\CMSIS\CM3\CoreSupport; common\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; common\efm32lib\inc; common\nrf24l01p
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: common\CMSIS\CM3\CoreSupport; common\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; common\efm32lib\inc; common\drivers
  OBJCOPY.OOCOutputFile: ElecStim.bin
  ILINK.IlinkOutputFile: blink.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG210F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\CM3\CoreSupport; ..\..\..\..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; ..\..\..\..\..\efm32lib\inc; ..\..\..\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: blink.bin
  group CMSIS
    common/CMSIS/CM3/CoreSupport/: core_cm3.c
    common/CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/startup/iar/: startup_efm32tg.s
    common/CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/: system_efm32.c
  group EFM32Lib
    common/efm32lib/src/: efm32_adc.c efm32_assert.c efm32_cmu.c efm32_dac.c efm32_dma.c efm32_emu.c efm32_gpio.c efm32_letimer.c efm32_opamp.c efm32_system.c efm32_timer.c efm32_usart.c
  group Nordic
    common/nrf24l01p/: hal_nrf.c hal_nrf.h hal_nrf_hw.c hal_nrf_hw.h hal_nrf_reg.h hardware.h hardware_devkit.h nordic_common.h
  group Source
    ./: main.c prog_types.h radio.c radio.h stim.c
